## boards/shields/mini_3_chocv2/Kconfig.defconfig
```kconfig
if SHIELD_MINI_3_CHOCV2

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "mini-3-chocv2"

endif
```
